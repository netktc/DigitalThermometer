# IAR project DigitalThermometer.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L152C6 STM8L152C6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8L15X_MD
  ICCSTM8.CCIncludePath2: inc; Libraries\STM8L15x_StdPeriph_Driver\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: DigitalThermometer.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group STM8L15x_StdPeriph_Driver/inc
    Libraries/STM8L15x_StdPeriph_Driver/inc/: stm8l15x.h stm8l15x_adc.h stm8l15x_clk.h stm8l15x_exti.h stm8l15x_gpio.h stm8l15x_lcd.h stm8l15x_rtc.h
  group STM8L15x_StdPeriph_Driver/src
    Libraries/STM8L15x_StdPeriph_Driver/src/: stm8l15x_adc.c stm8l15x_clk.c stm8l15x_exti.c stm8l15x_gpio.c stm8l15x_lcd.c stm8l15x_rtc.c
  group User/inc
    inc/: delay.h ds18b20.h main.h stm8l15x_conf.h stm8l15x_it.h stm8l_discovery_lcd.h
  group User/src
    src/: delay.c ds18b20.c stm8l15x_it.c stm8l_discovery_lcd.c
    ./: main.c
