<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\DigitalThermometer.ewp</path>
    </project>
    <batchBuild />
</workspace>
